## boards/shields/martlet/Kconfig.defconfig
```kconfig
if SHIELD_MARTLET

# Name must be less than 16 characters long!
config ZMK_KEYBOARD_NAME
    default "Martlet"

endif
```
